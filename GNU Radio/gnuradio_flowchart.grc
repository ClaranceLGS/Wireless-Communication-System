options:
  parameters:
    author: gurrutchalla
    generate_options: no_gui
    id: assembled9
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.43e9
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: 12000*2
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'True'
    polys: '[109,79]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: 12000*2
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'True'
    polys: '[109,79]'
    rate: '2'
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet length"'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '62.8319e-3'
  states: {}
- name: message_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[+0.7071+0.7071j, -0.7071+0.7071j, +0.7071-0.7071j, -0.7071-0.7071j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: 3552000*8
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: excess_bw
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts
    sym_rate: 1.0/sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: scale
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_char_to_float_1_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/vijithan/Documents/Octave/recieved1.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/vijithan/Documents/Octave/image_bin1.txt
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: scale
  states: {}
- name: blocks_matrix_interleaver_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '4'
    deint: 'False'
    rows: '4'
    type: byte
    vlen: '16'
  states: {}
- name: blocks_matrix_interleaver_0_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '4'
    deint: 'True'
    rows: '4'
    type: byte
    vlen: '16'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.8'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0_2_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_2_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_2_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_2_1_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: scale
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_key
    packet_len: message_size
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: data
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    name: data
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 96e3
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 96e3
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_1_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/gurrutchalla/Documents/GNURadio/output_audio.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/vijithan/Music/Interstellar new ringtone space Bgmwav.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.00005'
    freq_offset: '1e-4'
    noise_voltage: '1.3'
    seed: '0'
    taps: taps
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: len_key
    threshold: '3'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8a'
    seed: '0x7F'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: '4.0'
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_scrambler_bb_0_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """Packet Format"""

          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Packet Format",
                  in_sig=None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self,msg):
              inMsg = pmt.to_python (msg)
              pld = inMsg[1]
              # print (pld)
              mLen = len(pld)
              # print (mLen)
              if (mLen > 0):
                  char_list = [85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,225,90,232,147]
                  char_list.append (mLen >> 8)
                  char_list.append (mLen & 255)
                  char_list.append (mLen >> 8)
                  char_list.append (mLen & 255)
                  char_list.extend (pld)
                  #char_list.extend ([85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85])
                  # print (char_list)
                  out_len = len(char_list)
                  # print (out_len)
                  #output_items[0][:] = char_list
                  self.message_port_pub(pmt.intern('PDU_out'), pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(out_len,(char_list))))
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"546347d883b94ee1b242d29471dcda33"'
    bb_gain0: '-18'
    bw0: rf_rate
    freq0: center_freq
    gain0: '0'
    if_gain0: '0'
    sample_rate: rf_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"d982b4465b16431e868bfd551e0c8a18"'
    bb_gain0: '20'
    bw0: rf_rate
    freq0: center_freq
    gain0: '6'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: rf_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: 3552000*8
    fbw: '0.4'
    interp: '3552000'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '3552000'
    fbw: '0.4'
    interp: 3552000*8
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_transmit
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: to_channel
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: from_recieved
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: from_channel
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: pkt_out2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: to_transmit
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: from_channel
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: to_channel
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pkt_out2
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: from_recieved
  states: {}
- name: vocoder_ulaw_decode_bs_0
  id: vocoder_ulaw_decode_bs
  parameters: {}
  states: {}
- name: vocoder_ulaw_encode_sb_0
  id: vocoder_ulaw_encode_sb
  parameters: {}
  states: {}

connections:
- [audio_source_0, '0', blocks_stream_mux_0, '0']
- [audio_source_0, '1', blocks_stream_mux_0, '1']
- [blocks_char_to_float_1_2_0, '0', fec_extended_decoder_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', vocoder_ulaw_encode_sb_0, '0']
- [blocks_matrix_interleaver_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_matrix_interleaver_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', osmosdr_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0_2_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_2_1, '0', blocks_stream_to_vector_0, '0']
- [blocks_pack_k_bits_bb_0_0_2_1_0, '0', virtual_sink_0_1, '0']
- [blocks_pack_k_bits_bb_0_0_2_1_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_short_to_float_0, '0', blocks_stream_demux_0, '0']
- [blocks_stream_demux_0, '0', audio_sink_0, '0']
- [blocks_stream_demux_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_stream_demux_0, '1', audio_sink_0, '1']
- [blocks_stream_demux_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_stream_mux_0, '0', blocks_float_to_short_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', pdu_tagged_stream_to_pdu_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_matrix_interleaver_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_matrix_interleaver_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0_0, '0', vocoder_ulaw_decode_bs_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0, '0', digital_descrambler_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_1_1_0_0, '0', fec_extended_encoder_0, '0']
- [blocks_unpack_k_bits_bb_0_1_1_0_0_0, '0', digital_scrambler_bb_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_wavfile_source_0, '0', blocks_stream_mux_0, '0']
- [blocks_wavfile_source_0, '1', blocks_stream_mux_0, '1']
- [channels_channel_model_0, '0', rational_resampler_xxx_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0_0_2_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_descrambler_bb_0, '0', virtual_sink_1_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0_1_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_1_2_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_scrambler_bb_0_0, '0', blocks_pack_k_bits_bb_0_0_2_1_0_0, '0']
- [epy_block_0, PDU_out, pdu_pdu_to_tagged_stream_0, pdus]
- [fec_extended_decoder_0, '0', blocks_pack_k_bits_bb_0_0_2_1_0, '0']
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_0_0_2_1, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0_1_1_0_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_1, pdus, epy_block_0, PDU_in]
- [rational_resampler_xxx_0_0_0, '0', virtual_sink_0_2, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0, '0', blocks_unpack_k_bits_bb_0_1_1_0_0, '0']
- [virtual_source_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_0_1, '0', rational_resampler_xxx_0_1, '0']
- [virtual_source_1, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_1_0, '0', blocks_throttle_0_0, '0']
- [vocoder_ulaw_decode_bs_0, '0', blocks_short_to_float_0, '0']
- [vocoder_ulaw_encode_sb_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
